Commit message: usd inspect

File: openarm_description-main/v1_camera_isaac.urdf (robot description, URDF)
Before this commit: robot openarm, 28 links, 27 joints
Links:
- removed link world
Joints:
- removed joint openarm_body_world_joint
